PROGRAM MAIN
VAR
	var01:INT :=100;
	var02:INT  :=200; 
END_VAR

;

END_PROGRAM
